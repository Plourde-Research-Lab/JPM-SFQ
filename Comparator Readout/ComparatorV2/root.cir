* Generated by Xic from cell root
.tran .5p 20n
.plot tran LJPM#branch LC#branch v(3.x0)  v(3.x3) LT0#branch LT0#branch - LC#branch
.model jjs jj(rtype=1, icrit=1u, vshunt=90u, cap=40f)
.options ysep
.temp -272
.tran 1p 20n uic
B4 4 0 16 jjs area=1
BB 3 6 15 jjs area=70
BE1 8 2 12 jjs area=100
BE2 8 0 13 jjs area=100
BQ 10 0 17 jjs area=15
BT 2 3 14 jjs area=70
I2 6 3 gauss 87n 0 0
IBS 0 3 55.5u
IRABI 5 0 pulse -1u 1u 0 5p 5p 2.5n 5n
IT 0 2 50u
K1 LJPM LC 0.09
K2 LJPM L2 1
L2 5 0 1n
LC 3 10 22p
LJPM 4 0 1n
LT0 6 0 0.1p
V0 1 0 gpulse 0 0 100p 3.6p .5n
X0 1 7 JTL
X1 7 8 JTL
X2 3 9 JTL
X3 9 11 JTL
.subckt JTL 4 5
B0 2 0 6 jjs area=100
B1 3 0 7 jjs area=100
I0 0 1 150u
LT0 4 2 5p
LT1 2 1 5p
LT2 1 3 5p
LT3 3 5 5p
.ends JTL
.save @I0.X0[c]
.save @I0.X1[c]
.save @I0.X2[c]
.save @I0.X3[c]
.save @IT[c]
.save @IBS[c]
.save @IRABI[c]
.save @I2[c]
