* Generated by Xic from cell root
.tran 5p 25n
.model jjs jj(rtype=1, icrit=1u, vshunt=90u, cap=40f)
.options ysep
.temp -272
BE1 6 2 10 jjs area=100
BE2 6 0 11 jjs area=100
BT 2 3 12 jjs area=70
BB 3 0 13 jjs area=70
BQ 8 0 14 jjs area=15
IT 0 2 53.6u
IB 0 3 54.8u
Iq 6 3 gauss 20n 0 0
LC 3 8 20p
K1 LJPM LC 0.09
IJPM 4 0 0.4u
LJPM 4 0 1n
V0 1 0 gpulse 0 0 20p 3.6p .25n
X0 1 5 JTL
X1 5 6 JTL
X2 3 7 JTL
X3 7 9 JTL
.subckt JTL 4 5
B0 2 0 6 jjs area=100
B1 3 0 7 jjs area=100
I0 0 1 150u
LT0 4 2 5p
LT1 2 1 5p
LT2 1 3 5p
LT3 3 5 5p
.ends JTL
.control
run
*plot tran LJPM#branch v(1) v(3.x0) v(3.x1) LC#branch v(3) v(3.x3)
write cmp_sp.wrdata LJPM#branch LC#branch v(1) v(3.X0) v(3.X3) v(7.X0)/2/pi v(7.X3)/2/pi
.endc
