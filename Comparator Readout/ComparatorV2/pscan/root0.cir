* Generated by Xic from cell root
J0 3 1 J(J0*xj)
J1 8 1 J(J1*xj)
J2 1 0 J(J2*xj)
I0 0 2 I0*xi
I1 0 1 I1*xi
I2 0 4 I2*xi
M1 0 LLM(LC, LJPM, M1*xm)
LC 3 0 LC*xl
LJPM 2 0 LJPM*xl
LT1 4 8 LT1*xl
LT2 9 1 LT2*xl
P0 6 0 P0
X0 6 5 JTL
X1 5 7 JTL
X2 7 4 JTL
X3 9 10 JTL
X4 10 11 JTL
X5 11 15 JTL
.subckt JTL IN OUT
J0 4 0 J(J0*xj)
J1 5 0 J(J1*xj)
I0 0 3 I0*xi
L0 IN 4 L1*xl
L1 4 3 L1*xl
L2 3 5 L1*xl
L3 5 OUT L1*xl
.ends JTL
