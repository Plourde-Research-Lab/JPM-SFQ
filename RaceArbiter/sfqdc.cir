* Generated by Xic from cell sfqdc
.tran 1p 20n
B1 6 7 16 jjs area=6.45
B2 3 8 17 jjs area=14.55
B3 10 13 19 jjs area=5.3
B4 3 9 18 jjs area=7.25
B5 11 14 20 jjs area=10.9
B6 4 OUT 21 jjtl area=5.15
B7 OUT 15 22 jjs area=6.3
I1 0 5 11.2u
I2 0 OUT 5.45u
L1 10 12 58.6p
L2 12 11 31p
L3 IN 6 73.8p
L4 5 3 9.2p
L5 6 5 22.4p
LJ1 7 0 4p
LJ2 8 10 16.5p
LJ3 13 0 10.5p
LJ4 9 11 19.8p
LJ5 14 0 58p
LJ6 4 12 3.3p
LJ7 15 0 6.6p
R0 4 0 44
.save @I1[c]
.save @I2[c]
