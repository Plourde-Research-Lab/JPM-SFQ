* Generated by Xic from cell root2
J0 2 0 J(J1*xj)
J1 3 0 J(J1*xj)
J2 15 0 J(J1*xj)
J3 8 0 J(J1*xj)
I0 0 3 IC
I1 0 7 IJPM
I2 0 8 IC
M1 0 llm(L2, L3, M1*xm)
M2 0 llm(L0, L2, M1*xm)
L0 2 4 L1
L1 3 6 L1
L2 7 0 LJPM
L3 12 15 L1
L4 8 14 L1
V0 5 0 P0
V1 13 0 P1
X0 3 1 fjtl
X1 5 4 5PTL
X2 2 6 5PTL
X3 10 1 9 dff
X4 8 10 fjtl
X5 9 11 fjtl
X6 11 18 sfqdc
X7 13 12 5PTL
X8 15 14 5PTL
.subckt dff DATA CLK OUT
J0 4 5 6 J(J1*xj)
J OUT 0 7 J(J1*xj)
L0 CLK 4 L0
L1 5 DATA L1
L2 OUT 5 L2
.ends dff
.subckt sfqdc IN OUT
J1 6 7 J?
J2 3 8 J?
J3 10 13 J?
J4 3 9 J?
J5 11 14 J?
J6 4 OUT JT(J6*xj, B)
J7 OUT 15 J?
I1 0 5 I1
I2 0 OUT I2
L1 10 12 L?
L2 12 11 L?
L3 IN 6 L?
L4 5 3 L?
L5 6 5 L?
LJ1 7 0 L?
LJ2 8 10 L?
LJ3 13 0 L?
LJ4 9 11 L?
LJ5 14 0 L?
LJ6 4 12 L?
LJ7 15 0 L?
R1 4 0 R1
.ends sfqdc
.subckt ptl IN OUT
J1 OUT 3 4 JT(J1*xj)
L0 IN OUT L?
L1 3 0 L?
.ends ptl
.subckt fjtl IN OUT
B0 4 0 6 J(J1*xj)
B1 5 0 7 J(J1*xj)
I0 0 3 I0
L0 4 IN L?
L1 3 4 L?
L2 5 3 L?
L3 OUT 5 L?
.ends fjtl
.subckt 5PTL IN OUT
X0 IN 3 ptl
X1 3 4 ptl
X2 4 5 ptl
X3 5 6 ptl
X4 6 OUT ptl
.ends 5PTL
