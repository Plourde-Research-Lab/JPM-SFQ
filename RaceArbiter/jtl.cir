* Generated by Xic from cell jtl
.tran 1p 50p
IBias 0 OUT pwl 0 0 10p $ibias
LJTL IN OUT $ljtl
.save @IBias[c]
