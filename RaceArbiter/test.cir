* Generated by Xic from cell root
.tran 1p 10n
.plot tran v(1) i( L2#branch) v(3) v(13) v(6) v(14)
.options ysep
.model jjtl jj(rtype=1, icrit=1u, cap=40f, r0=30, rn=30)
.temp -272
B0 2 0 12 jjtl area=2
B1 4 0 15 jjtl area=2
I0 0 2 pwl 0 0 5p $ibias
I1 0 9 pwl 0 0 5p .9u 4.9n .9u 5.0n -.9u 10n -.9u
I2 0 4 pwl 0 0 5p $ibias
K1 L0 L2 $k
K2 L2 L3 $k
L0 2 8 $ljtl
L1 7 3 5p
L2 9 10 $ljpm
L3 5 4 $ljtl
L4 11 6 5p
R0 10 0 1
V0 1 0 gpulse 0 0 50p 1p 5n
X0 7 13 bjtl
X1 1 8 5celljtl
X2 2 3 5celljtl
X3 11 14 bjtl
X4 1 5 5celljtl
X5 4 6 5celljtl
.subckt 5celljtl IN OUT
.ends 5celljtl
.subckt bjtl IN OUT
B0 4 0 6 jjtl area=10
B1 5 0 7 jjtl area=10
I0 0 3 15u
L0 IN 4 5p
L1 4 3 5p
L2 3 5 5p
L3 5 OUT 5p
.ends bjtl
.subckt jtl IN OUT
.model jjd jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m,
+ icrit=1u, r0=30, rn=1.7, cap=1f)
B0 4 0 6 jjd area=14
B1 5 0 7 jjd area=14
I0 0 3 9.9u
L0 IN 4 32p
L1 4 3 32p
L2 3 5 32p
L3 5 OUT 32p
.ends jtl
.save @I0.X0.X1[c]
.save @I0.X1.X1[c]
.save @I0.X2.X1[c]
.save @I0.X3.X1[c]
.save @I0.X4.X1[c]
.save @I0.X0.X2[c]
.save @I0.X1.X2[c]
.save @I0.X2.X2[c]
.save @I0.X3.X2[c]
.save @I0.X4.X2[c]
.save @I0.X0.X4[c]
.save @I0.X1.X4[c]
.save @I0.X2.X4[c]
.save @I0.X3.X4[c]
.save @I0.X4.X4[c]
.save @I0.X0.X5[c]
.save @I0.X1.X5[c]
.save @I0.X2.X5[c]
.save @I0.X3.X5[c]
.save @I0.X4.X5[c]
.save @I0.X0[c]
.save @I0.X3[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
