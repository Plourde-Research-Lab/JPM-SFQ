* Generated by Xic from cell root
.tran 1p 4n
.plot tran L7#branch v(2) v(4)
.model jjtl jj(rtype=1, icrit=1u, cap=40f, r0=10k, rn=1k)
.model jjs jj(icrit=1u, cap=40f, r0=30, rn=30)
.temp -272
B0 5 0 22 jjtl area=2
B1 11 0 23 jjs area=10
B2 1 0 24 jjs area=10
B3 12 0 25 jjs area=10
B4 2 0 26 jjs area=10
B5 19 0 27 jjtl area=2
B6 20 0 28 jjs area=10
B7 3 0 29 jjs area=10
B8 21 0 30 jjs area=10
B9 4 0 31 jjs area=10
I0 0 6 18u
I1 0 7 16u
I2 0 13 pulse -1u 1u 0 5p 5p 1n 2n
I3 0 14 18u
I4 0 15 16u
K1 L7 L0 $k1
K2 L7 L8 -$k1
L0 8 5 41p
L1 11 6 5p
L2 6 1 5p
L3 12 7 50p
L4 7 2 50p
L5 11 10 5p
L6 12 1 20p
L7 13 0 1n
L8 16 19 41p
L9 20 14 5p
L10 14 3 5p
L11 21 15 50p
L12 15 4 50p
L13 20 18 5p
L14 21 3 20p
V0 9 0 gpulse 0 0 50p 1p 1n
V1 17 0 gpulse 0 0 50p 1p 1n
X0 9 8 5PTL
X1 5 10 5PTL
X2 17 16 5PTL
X3 19 18 5PTL
.subckt ptl IN OUT
B0 OUT 3 4 jjtl area=2
L0 IN OUT 41p
L1 3 0 .1p
.ends ptl
.subckt 5PTL IN OUT
X0 IN 3 ptl
X1 3 4 ptl
X2 4 5 ptl
X3 5 6 ptl
X4 6 OUT ptl
.ends 5PTL
.save @I1[c]
.save @I4[c]
.save @I2[c]
.save @I3[c]
.save @I0[c]
