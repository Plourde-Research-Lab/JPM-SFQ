* Generated by Xic from cell root
.tran 1p 20n
.plot tran i( L2#branch) v(1) v(5) v(11)
.model jjtl jj(rtype=1, icrit=1u, cap=40f, r0=30, rn=30)
.temp -272
.options ysep
B0 2 0 14 jjtl area=2
B1 3 0 15 jjtl area=2
I0 0 2 pwl 0 0 5p $ibias
I1 0 9 pulse -1u 1u 0 5p 5p 5n 10n
I2 0 3 pwl 0 0 5p $ibias
K1 L0 L2 $k1
K2 L2 L3 $k2
L0 2 7 $ljtl
L1 6 8 5p
L2 9 10 $ljpm
L3 4 3 $ljtl
L4 12 13 5p
R0 5 0 8
R1 10 0 1
R2 11 0 8
V0 1 0 gpulse 0 0 50p 1p 5n
X0 6 5 bjtl
X1 1 7 5PTL
X2 2 8 5PTL
X3 12 11 bjtl
X4 1 4 5PTL
X5 3 13 5PTL
.subckt ptl IN OUT
B0 OUT 3 4 jjtl area=2
L0 IN OUT $ljtl
L1 3 0 .1p
.ends ptl
.subckt bjtl IN OUT
B0 4 0 6 jjtl area=10
B1 5 0 7 jjtl area=10
I0 0 3 15u
L0 IN 4 5p
L1 4 3 5p
L2 3 5 5p
L3 5 OUT 5p
.ends bjtl
.subckt 5PTL IN OUT
X0 IN 3 ptl
X1 3 4 ptl
X2 4 5 ptl
X3 5 6 ptl
X4 6 OUT ptl
.ends 5PTL
.save @I0.X3[c]
.save @I0.X0[c]
.save @I0[c]
.save @I1[c]
.save @I2[c]
