* Generated by Xic from cell underdamped_JTL
.options ysep
.options temp=-272

* SFQ IN
V1 VIN 0 gpulse 0 0 20p 2p 0 20p

* Bias
V0 VCC 0 pwl 0 0 1p .05m

* JPM Flux Bias
I0 0 6 pwl 0 0 1p $value1
K1 L3 L0 0.41
L0 6 0 26.7p

* JTL

L1 VIN 7 40p
B0 7 0 J1 jjud area=1
R0 VCC 7 100

L2 7 8 40p
B1 8 0 J2 jjud area=1
R1 VCC 8 100

L3 8 9 40p
B2 9 0 J3 jjud area=1
R2 VCC 9 100

L4 9 10 40p
B3 10 0 16 jjud area=1
R3 VCC 10 100

L5 10 11 40p
B4 11 0 17 jjud area=1
R4 VCC 11 100

L6 11 12 40p
B5 12 0 18 jjud area=1
R5 VCC 12 100

L7 12 13 40p
B6 13 0 19 jjud area=1
R6 VCC 13 100

L8 13 14 40p
B7 14 0 20 jjud area=1
R7 VCC 14 100

.model jjud jj(rtype=1, cct=1, vg=2.8m, icrit=2u, vshunt=0.5mV cap=300f)

.tran 1p 100p
.plot tran v(VIN) v(7) v(14)

.end
