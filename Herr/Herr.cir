* Generated by Xic from cell Herr
.tran .5p 100p
*.plot tran v(3) v(4) v(6) v(9) v(11) v(13) v(15)
.options ysep
.model jjtl jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m, icrit=2u, r0=50,rn=10,cap=300f)
.options temp=-269
.plot v(3) v(9) v(15)
I0 8 0 0
L0 1 3 2p
R0 15 0 11
V0 1 0 gpulse 0 0 50p 2p
X0 3 2 MJTL
X1 2 4 MJTL
X2 4 5 MJTL
X3 5 6 MJTL
X4 6 7 MJTL
X5 7 9 8 JPMJTL
X6 9 10 MJTL
X7 10 11 MJTL
X8 11 12 MJTL
X9 12 13 MJTL
X10 13 14 MJTL
X11 14 15 MJTL
.subckt JPMJTL IN OUT JPM
B0 6 0 7 jjtl area=1
I0 0 4 $value1
K1 LJPM LJTL .5
K2 LBias Lshunt .1
L3 6 OUT 2p
LBias 0 4 55p
LJPM JPM 0 1n
LJTL IN OUT 41p
Lshunt 0 5 3.2n
R0 5 OUT .001
.ends JPMJTL
.subckt MJTL IN OUT
B0 5 0 6 jjtl area=1
I0 3 0 $value1
K1 LBias Lshunt .1
L3 OUT 5 0
LBias 0 3 55p
LJTL IN OUT 41p
Lshunt 0 4 3.2n
R0 4 OUT .001
.ends MJTL
.save @I0.X5[c]
.save @I0.X6[c]
.save @I0.X0[c]
.save @I0.X3[c]
.save @I0.X4[c]
.save @I0.X7[c]
.save @I0.X1[c]
.save @I0.X2[c]
.save @I0.X8[c]
.save @I0.X9[c]
.save @I0.X10[c]
.save @I0.X11[c]
.save @I0[c]
