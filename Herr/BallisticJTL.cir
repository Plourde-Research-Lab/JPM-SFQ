* Generated by Xic from cell BallisticJTL
.model jjud jj(rtype=0,cct=1,icon=10m,vg=2.4m,delv=0.08m,icrit=1.00E-6,cap=50f)
.options ysep
.temp -272.9
IJPM 0 5 pwl 0 0 5p $value1
R0 1 0 9
R1 3 0 9
V0 1 0 gpulse 0 0 20p 2p
X0 1 6 JTLA
X1 6 7 JTLA
X2 7 8 JTLA
X3 8 9 JTLA
X4 9 10 JTLA
X5 10 11 JTLA
X6 11 12 JTLA
X7 12 13 JTLA
X8 13 14 JTLA
X9 14 2 JTLA
X10 2 4 5 JTLM
X11 15 3 JTLA
X12 16 15 JTLA
X13 17 16 JTLA
X14 18 17 JTLA
X15 19 18 JTLA
X16 20 19 JTLA
X17 21 20 JTLA
X18 22 21 JTLA
X19 23 22 JTLA
X20 4 23 JTLA
.subckt JTLA IN OUT
B0 OUT 0 3 jjud area=1
I0 0 OUT pwl 0 0 5p 0
L0 IN OUT 4p
.ends JTLA
.subckt JTLM IN OUT BIAS
B0 OUT 0 4 jjud area=1
I0 0 OUT pwl 0 0 5p 0
L0 IN BIAS 1n
L1 IN OUT 4p
.ends JTLM

.control

* set $value1=0
sweep -500u 500u 100u

plot v(1) v(3)
.endc

.tran .5p 100p
