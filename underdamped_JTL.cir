* Generated by Xic from cell underdamped_JTL
.tran 1p 250p
.plot tran v(VIN) v(7) v(VCC)
.options ysep
B0 7 0 J1 jjud area=1
B1 8 0 J2 jjud area=1
B2 9 0 J3 jjud area=1
B3 10 0 16 jjud area=1
B4 11 0 17 jjud area=1
B5 12 0 18 jjud area=1
B6 13 0 19 jjud area=1
B7 14 0 20 jjud area=1
I0 0 6 pwl 0 0 1p .1m
K1 L3 L0 0.41
L0 6 0 26.7p
L1 VIN 7 40p
L2 7 8 40p
L3 8 9 40p
L4 9 10 40p
L5 10 11 40p
L6 11 12 40p
L7 12 13 40p
L8 13 14 40p
R0 VCC 7 100
R1 VCC 8 100
R2 VCC 9 100
R3 VCC 10 100
R4 VCC 11 100
R5 VCC 12 100
R6 VCC 13 100
R7 VCC 14 100
V0 VCC 0 pwl 0 0 1p .05m
V1 VIN 0 gpulse 0 0 20p 2p 0 20p
.model jjud jj(rtype=1, cct=1, vg=2.8m, icrit=2u, vshunt=0.5mV cap=300f)
.save @I0[c]
