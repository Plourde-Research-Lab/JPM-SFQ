* Generated by Xic from cell SFQ_Delay_3
.tran 1p 1n
.plot tran v(VCLK) v(SFQIN) v(JTL1) v(LOUT) v(13) v(JTL2)
.options ysep
.save savetest
K1 L0 L2 0.001
L0 12 0 1p
L1 SFQIN 10 1.05pH
L2 JTL1 LOUT 2.1p
L3 13 JTL2 1.05pH
R0 11 12 1M
R1 VCLK DCIN 1k
R2 DCOUT 0 10.8
R3 RGND 0 1.2
Vbias VCC 0 pwl 0 0 10p 10m
Vclk VCLK 0 pulse 0 500m 20p 50p 50p 100p 300p
Vdelay 0 11 pwl 0 0 10p 10m
X0 DCIN SFQIN VCC dcsfq
X1 JTL2 DCOUT RGND VCC sfqdc
X2 10 JTL1 VCC jtl
X3 LOUT 13 VCC jtl
.subckt sfqdc IN OUT RGND VBIAS
B0 15 0 32 jjr area=.34
B1 17 16 33 jjr area=.17
B2 18 6 34 jjr area=.25
B3 19 20 35 jjr area=.22
B4 9 21 36 jjr area=.13
B5 22 24 37 jjr area=.3
B6 20 25 38 jjr area=.22
B7 23 26 39 jjr area=.22
B8 28 30 40 jjr area=.17
B9 29 31 41 jjr area=.34
L0 10 18 11.3pH
LP0 16 0 0.13pH
LP1 5 6 .26pH
LP2 8 11 0.08pH
LP3 22 11 0.50pH
LP4 21 23 0.45pH
LP5 10 23 0.26pH
LP6 24 0 0.11pH
LP7 26 0 0.40pH
LP8 12 14 0.53pH
LP9 27 29 .53pH
LP10 28 14 0.16pH
LP11 31 0 0.16pH
LP12 30 0 0.11pH
LT0 15 7 1.84pH
LT1 6 RGND 0.63pH
LT2 17 7 0.84pH
LT3 17 19 0.50pH
LT4 7 9 1.87pH
LT5 IN 22 1.98pH
LT6 11 20 1.29pH
LT7 10 OUT 0.24pH
LT8 9 13 2.00pH
LT9 25 28 0.55pH
LT10 14 13 1.34pH
LT11 13 29 1.08pH
R0 5 VBIAS 22
R1 VBIAS 8 31
R2 VBIAS 12 57
R3 VBIAS 27 44
.ends sfqdc
.subckt dcsfq IN OUT VBIAS
B0 9 5 15 jjr area=.17
B1 10 11 16 jjr area=.25
B2 12 13 17 jjr area=.15
B3 7 14 18 jjr area=.17
L0 12 0 3.58pH
LP0 8 6 0.08pH
LP1 4 9 1.29pH
LP2 5 6 1.13pH
LP3 6 10 1.74pH
LP4 5 7 0.21pH
LP5 4 12 1.27pH
LP6 11 0 0.13pH
LP7 13 7 0.69pH
LP8 14 0 0.18pH
LT0 10 OUT 2.11pH
LT1 IN 4 3.38pH
R0 VBIAS 8 27
.ends dcsfq
.subckt jtl IN OUT VBIAS
B0 5 7 9 jjr area=.25
B1 6 8 10 jjr area=.25
LP0 7 0 .1pH
LP1 8 0 .1pH
LT0 IN 5 2.1pH
LT1 5 4 2.1pH
LT2 4 6 2.1pH
LT3 6 OUT 2.1pH
R0 VBIAS 4 29
.ends jtl
.model jjr jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m,
+ icrit=1m, vshunt=0.5mV cap=1.31p)

* YBCO
