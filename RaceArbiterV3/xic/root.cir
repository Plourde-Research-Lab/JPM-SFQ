* Generated by Xic from cell root
.tran 1p 10n
.plot tran v(1) v(15)
.temp -272
.model jju jj(rtype=1, icrit=1u, rn=30, r0=30, cap=40f)
.model jjs jj(rtype=1, icrit=1u, cap=40f, vshunt=90u)
B0 4 0 23 jju area=1
B1 22 0 26 jju area=1
I0 0 5 $ic
I1 0 13 pulse -1u 1u 0 5p 5p 5n 10n
I2 0 19 $ic
K1 LT1 LT2 -$k1
K2 LT1 LT0 $k1
LT0 4 11 40p
LT1 13 0 1n
LT2 22 21 40p
V0 6 0 gpulse 0 0 3n 1p 5n
V1 12 0 gpulse 0 0 0.5n 1p 5n
X0 6 2 7 mrg
X1 7 8 JTL1
X2 5 9 JTL1
X3 9 10 JTL1
X4 10 1 JTL1
X5 8 11 bjtl5
X6 4 5 bjtl5
X7 12 2 3 spl
X8 15 1 14 dff
X9 3 24 16 mrg
X10 16 17 JTL1
X11 19 18 JTL1
X12 18 20 JTL1
X13 20 15 JTL1
X14 14 25 JTL
X15 17 21 bjtl5
X16 22 19 bjtl5
.subckt bjtl5 IN OUT
B0 3 0 7 jju area=2
B1 4 0 8 jju area=2
B2 5 0 9 jju area=2
B3 6 0 10 jju area=2
B4 OUT 0 11 jju area=2
LT0 IN 3 41p
LT1 3 4 41p
LT2 4 5 41p
LT3 5 6 41p
LT4 6 OUT 41p
.ends bjtl5
.subckt dff DATA CLK OUT
B0 4 5 7 jjs area=10
B1 OUT 6 8 jjs area=10
LP0 6 0 3.3p
LQ0 DATA 5 222.7p
LT0 CLK 4 32.9p
LT1 5 OUT 6.59p
.ends dff
.subckt JTL1 IN OUT
B0 4 0 5 jjs area=10
B1 OUT 0 6 jjs area=10
I0 0 3 15u
LT0 IN 4 100p
LT1 4 3 50p
LT2 3 OUT 50p
.ends JTL1
.subckt spl IN OUT1 OUT2
B0 5 0 7 jjs area=10
B1 IN 0 8 jjs area=10
B2 6 0 9 jjs area=10
I0 0 4 22.5u
LT0 4 5 50p
LT1 5 OUT1 100p
LT2 IN 4 50p
LT3 4 6 50p
LT4 6 OUT2 100p
.ends spl
.subckt JTL IN OUT
B0 4 0 6 jjs area=10
B1 5 0 7 jjs area=10
I0 0 3 17u
LT0 IN 4 100p
LT1 4 3 50p
LT2 3 5 50p
LT3 5 OUT 100p
.ends JTL
.subckt mrg IN1 IN2 OUT
B0 6 7 15 jjs area=10
B1 8 4 16 jjs area=9
B2 4 11 17 jjs area=9
B3 10 12 18 jjs area=10
B4 13 14 19 jjs area=10
I0 0 9 20.5u
LP0 0 6 0.66p
LP1 7 8 16.5p
LP2 5 9 3.3p
LP3 4 5 16.5p
LP4 11 13 16.5p
LP5 12 0 0.66p
LP6 14 0 0.66p
LT0 IN1 7 50p
LT1 5 10 66p
LT2 10 OUT 50p
LT3 IN2 13 50p
.ends mrg

.exec
set ic=0u
set k1=0.063
.endc
