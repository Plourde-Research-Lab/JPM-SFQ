* Generated by Xic from cell root
.tran 1p 10n
.plot tran i(LT1) v(1) v(12) v(13)
.temp -272
.options ysep
.model jju jj(rtype=1, icrit=1u, rn=30, r0=30, cap=40f)
.model jjs jj(rtype=1, icrit=1u, cap=40f, vshunt=90u)
B0 2 0 11 jju area=1
B1 10 0 14 jju area=1
I0 0 3 $ic
I1 0 6 pulse -1u 1u 0 5p 5p 5n 10n
I2 0 8 $ic
K1 LT1 LT2 -$k1
K2 LT1 LT0 $k1
LT0 2 5 40p
LT1 6 0 1n
LT2 10 9 40p
V0 1 0 gpulse 0 0 1n 1p 5n
X0 1 4 JTL1
X1 3 12 JTL
X2 4 5 bjtl5
X3 2 3 bjtl5
X4 1 7 JTL1
X5 8 13 JTL
X6 7 9 bjtl5
X7 10 8 bjtl5
.subckt bjtl5 IN OUT
B0 3 0 7 jju area=2
B1 4 0 8 jju area=2
B2 5 0 9 jju area=2
B3 6 0 10 jju area=2
B4 OUT 0 11 jju area=2
LT0 IN 3 41p
LT1 3 4 41p
LT2 4 5 41p
LT3 5 6 41p
LT4 6 OUT 41p
.ends bjtl5
.subckt JTL1 IN OUT
B0 4 0 5 jjs area=10
B1 OUT 0 6 jjs area=10
I0 0 3 15u
LT0 IN 4 100p
LT1 4 3 50p
LT2 3 OUT 50p
.ends JTL1
.subckt JTL IN OUT
B0 4 0 6 jjs area=10
B1 5 0 7 jjs area=10
I0 0 3 17u
LT0 IN 4 100p
LT1 4 3 50p
LT2 3 5 50p
LT3 5 OUT 100p
.ends JTL

.control
set ic=value1
sweep
.endc
