* Generated by Xic from cell root
.tran 1p 20n
.plot tran v(1) v(5)
.options ysep
.temp -272
.include root_models.inc
.tran 1p 20n uic
V0 1 0 gpulse(0 0 0.1n 1p 0.5n)
X0 1 4 JTL
X0_0 2 3 CMP
X1 4 5 JTL
X2 5 2 JTL
X4 3 6 JTL
X5 6 7 JTL
.subckt JTL 4 5
B0 2 0 6 jjs area=100
B1 3 0 7 jjs area=100
I0 0 1 150u
LT0 4 2 5p
LT1 2 1 5p
LT2 1 3 5p
LT3 3 5 5p
.ends JTL
.subckt CMP 4 2
BB 2 0 9 jjs area=4
BE1 4 1 6 jjs area=4
BE2 4 0 7 jjs area=4
BQ 5 0 10 jjs area=1
BT 1 2 8 jjs area=4
IBS 0 2 $ib
IRABI 3 0 pulse -1u 1u 0 5p 5p 2n 4n
IT 0 1 $it
K1 LJPM LC 0.1
LC 2 5 60p
LJPM 3 0 1.2n
.ends CMP
