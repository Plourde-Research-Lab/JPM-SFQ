* Generated by Xic from cell BallisticJTL
.model jjud jj(rtype=0,cct=1,icon=10m,vg=2.4m,delv=0.08m,icrit=1u,cap=5f)
.options ysep
.temp -272.9
R0 1 0 3
R1 11 0 3
V0 1 0 gpulse 0 0 20p 2p
X0 1 2 JTLA
X1 2 3 JTLA
X2 3 4 JTLA
X3 4 5 JTLA
X4 5 6 JTLA
X5 6 7 JTLA
X6 7 8 JTLA
X7 8 9 JTLA
X8 9 10 JTLA
X9 10 11 JTLA
.subckt JTLA IN OUT
B0 OUT 0 3 jjud area=2
I0 0 OUT pwl 0 0 5p $value1
L0 IN OUT .05p
.ends JTLA
.save @I0.X5[c]
.save @I0.X1[c]
.save @I0.X2[c]
.save @I0.X4[c]
.save @I0.X7[c]
.save @I0.X0[c]
.save @I0.X3[c]
.save @I0.X6[c]
.save @I0.X8[c]
.save @I0.X9[c]

.control
sweep 0 .5u 100n
plot v(1) v(6) v(11)
.endc
.tran .5p 100p
