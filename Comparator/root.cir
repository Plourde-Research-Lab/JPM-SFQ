* Generated by Xic from cell root
.tran 1p 1n
.plot tran LT0#branch v(7) v(12)/2/pi v(14)/2/pi v(13)
.model jjs jj(icrit=1u, cap=40f, vshunt=90u)
.temp -272
.options ysep
B0 1 5 11 jjs area=4
B1 1 0 12 jjs area=4
B2 10 1 14 jjs area=4
I0 0 4 pulse -1u 1u 0 5p 5p .5n 1n
I1 0 1 $i1
I2 0 2 $i2
K1 LT0 LT1 $k1
LT0 4 0 1n
LT1 5 0 60p
LT2 2 10 0p
LT3 1 3 0p
V0 7 0 gpulse 0 0 0.1n 1p 0.25n
X0 7 6 JTL
X1 6 8 JTL
X2 8 2 JTL
X3 3 9 JTL
X4 9 13 JTL
.subckt JTL IN OUT
B0 4 0 6 jjs area=4
B1 5 0 7 jjs area=4
I0 0 3 6u
LT0 IN 4 20.5p
LT1 4 3 20.5p
LT2 3 5 20.5p
LT3 5 OUT 20.5p
.ends JTL
.save @I0.X0[c]
.save @I0.X1[c]
.save @I0.X2[c]
.save @I0.X3[c]
.save @I0.X4[c]
.save @I2[c]
.save @I1[c]
.save @I0[c]
