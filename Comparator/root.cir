* Generated by Xic from cell root
.tran 1p 1n
.plot tran LJPM#branch v(6) v(8) v(1) v(15)
.model jjs jj(icrit=1u, cap=40f, vshunt=90u)
.temp -272
.options ysep
B0 3 1 12 jjs area=4
B1 8 1 13 jjs area=4
B2 1 0 14 jjs area=4
I0 0 2 pulse -1u 1u 0 5p 5p 0.5n 1n
I1 0 1 $ib1
I2 0 4 $ib2
K1 LC LJPM 0.1
LC 3 0 60p
LJPM 2 0 1n
LT1 4 8 1p
LT2 9 1 1p
V0 6 0 gpulse 0 0 0.1n 1p 0.25n
X0 6 5 JTL
X1 5 7 JTL
X2 7 4 JTL
X3 9 10 JTL
X4 10 11 JTL
X5 11 15 JTL
.subckt JTL IN OUT
B0 4 0 6 jjs area=5
B1 5 0 7 jjs area=5
I0 0 3 7.5u
LT0 IN 4 100p
LT1 4 3 100p
LT2 3 5 100p
LT3 5 OUT 100p
.ends JTL
