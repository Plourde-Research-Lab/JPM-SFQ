* Generated by Xic from cell root
.tran 1p 10n
.plot tran LJPM#branch v(4.x0) v(1) LC#branch v(15)
.model jjs jj(icrit=1u, cap=40f, vshunt=90u)
.temp -272
.options ysep
B1 1 0 14 jjs area=4
B1p 7 1 12 jjs area=4
B2 9 1 13 jjs area=4
I0 0 4 pulse -1u 1u 0 5p 5p 2n 4n
I1 0 1 9u
I2 0 8 8u
K1 LJPM LC 0.1
LC 7 0 60p
LJPM 4 0 645p
LT1 2 8 20.5p
LT2 8 9 20.5p
LT3 3 1 20.5p
V0 6 0 gpulse 0 0 0.1n 1p 0.5n
X0 6 5 JTL
X1 5 2 JTL
X2 3 10 JTL
X3 10 11 JTL
X4 11 15 JTL
.subckt JTL IN OUT
B0 4 0 6 jjs area=4
B1 5 0 7 jjs area=4
I0 0 3 6u
LT0 IN 4 20.5p
LT1 4 3 20.5p
LT2 3 5 20.5p
LT3 5 OUT 20.5p
.ends JTL
