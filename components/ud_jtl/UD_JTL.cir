* Generated by Xic from cell noname
.tran 1p 1n
B0 VCC 0 J1 jj3 area=1
B1 VCC 0 J2 jj3 area=1
B2 VCC 0 J3 jj3 area=1
B3 VCC 0 J4 jj3 area=1
L0 VIN VCC 39p
L1 VCC VCC 39p
L2 VCC VCC 39p
L3 VCC VCC 39p
V0 VCC 0 pwl 0 0 10p 10m
V1 VIN 0 gpulse 0 0 20p 2p 0 40p
.model jj3 jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m,
+ icrit=1m, r0=30, rn=1.7, cap=1.31p)
