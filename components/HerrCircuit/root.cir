* Generated by Xic from cell root
.options ysep
.model jjtl jj(rtype=0, icrit=1u, cap=300f, rn=1200, r0=12k)
.model jjshort jj(rtype=1,cct=1,icon=10m,vg=2.8m,delv=0.08m,icrit=1.00E-6,r0=30,rn=30,cap=50f)
I0 13 0 0
R0 25 0 11
V0 1 0 gpulse 0 0 20p 2p
X0 1 2 MJTL
X1 2 3 MJTL
X2 3 4 MJTL
X3 4 5 MJTL
X4 5 6 MJTL
X5 6 7 MJTL
X6 7 8 MJTL
X7 8 9 MJTL
X8 9 10 MJTL
X9 10 11 MJTL
X10 11 12 MJTL
X11 12 14 13 JPMJTL
X12 14 15 MJTL
X13 15 16 MJTL
X14 16 17 MJTL
X15 17 18 MJTL
X16 18 19 MJTL
X17 19 20 MJTL
X18 20 21 MJTL
X19 21 22 MJTL
X20 22 23 MJTL
X21 23 24 MJTL
X22 24 25 MJTL
.subckt JPMJTL IN OUT JPM
B0 6 7 9 jjshort area=1e6
B1 OUT 0 10 jjtl area=2.12
I0 0 4 21u
K1 LJPM LJTL .5
K2 LBias Lshunt .1
L3 7 OUT 1fH
LBias 0 5 5.5e-11
LJPM JPM 8 1n
LJTL IN 7 41p
Lshunt 0 6 1e-13
R0 4 5 1u
R1 8 0 1u
.ends JPMJTL
.subckt MJTL IN OUT
B0 5 OUT 6 jjshort area=1
B1 OUT 0 7 jjtl area=2.12
I0 0 3 $value1
K1 LBias Lshunt .1
LBias 0 4 5.5e-11
LJTL IN OUT 41p
Lshunt 0 5 1e-13
R0 3 4 1u
.ends MJTL
.save @I0.X6[c]
.save @I0.X7[c]
.save @I0.X17[c]
.save @I0.X16[c]
.save @I0.X1[c]
.save @I0.X2[c]
.save @I0.X15[c]
.save @I0.X5[c]
.save @I0.X13[c]
.save @I0.X18[c]
.save @I0.X12[c]
.save @I0.X0[c]
.save @I0.X14[c]
.save @I0.X3[c]
.save @I0.X10[c]
.save @I0.X19[c]
.save @I0.X4[c]
.save @I0.X9[c]
.save @I0.X22[c]
.save @I0.X21[c]
.save @I0.X20[c]
.save @I0.X8[c]
.save @I0.X11[c]
.save @I0[c]

.tran .5p 100p
.plot v(21) v(1)

.control
*
set $value1=0
* sweep 0 10u 1u
* * sweep $value2 -1u 1u 100n
* * set $value2=0
* run
plot v(1) v(2)
*
.endc
