* Generated by Xic from cell SU-UWM-Driver.xic

.options ysep
.options temp=-272

.include SU-UWM-Driver_models.inc

* Trigger In
itrig VIN 0 sin(0 4.47E-5 5e9)
rload VIN 0 50

* Input
l2 VIN 3 1.39E-11

* Bottom Path
l5 3 9 5.27E-12
l8 9 0 31.0E-12
b3 9 10 16 jjuw area=4.00E+0
r3 9 10 2.97E+0
lpj3 10 7 2.85E-12
b2 7 11 17 jjuw area=4.00E+0
r2 7 11 3.68E+0
lpj2 11 0 7.68E-13

* Upper Path
b1 1 2 13 jjuw area=3.00E+0
l4 3 1 5.38E-12
r1 1 2 5.50E+0
l10 2 7 8.78E-13
l6 2 4 4.72E-12
l13 4 JTL 7.24E-12

* Single cell JTL
b4 JTL 8 15 jjuw area=5.50E+0
lpj4 8 0 5.49E-13
r4 JTL 8 2.97E+0

* Bias Line
ibias 12 0 $value1
lpi1 12 4 3.29E-13

.tran 1p 1n
*.plot tran  v(6) v(5)
.end

.control
  set loopthrds = 4
  set biasCurrAmpStart = 5E-5
  set biasCurrAmpStop = 15E-5
  set biasCurrStep = .25E-5
  *sweep  -10e-5 -5e-5 1e-5
  *tran 1p 1n
  sweep -10e-5 -5e-5 1e-5

  run

  plot v(6) v(5)

  *write outV2.rawfile v(1) v(12)
.endc
