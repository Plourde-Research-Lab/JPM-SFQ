* Generated by Xic from cell SU-UWM-Driver.xic
.tran 1p 1n
.plot tran  v(6) v(5)
.options ysep
.include SU-UWM-Driver_models.inc
.tran 0.1e-12 450e-12
.options temp=-272
b1 1 2 13 jjuw area=3.00E+0
b2 7 11 17 jjuw area=4.00E+0
b3 9 10 16 jjuw area=4.00E+0
b4 5 8 15 jjuw area=5.50E+0
ibias 12 0 -8.25E-5
itrig 6 0 sin(0 4.47E-5 5e9)
l2 6 3 1.39E-11
l4 3 1 5.38E-12
l5 3 9 5.27E-12
l6 2 4 4.72E-12
l8 9 0 31.0E-12
l10 2 7 8.78E-13
l13 4 5 7.24E-12
lpi1 12 4 3.29E-13
lpj2 11 0 7.68E-13
lpj3 10 7 2.85E-12
lpj4 8 0 5.49E-13
r1 1 2 5.50E+0
r2 7 11 3.68E+0
r3 9 10 2.97E+0
r4 5 8 2.97E+0
rload 6 0 50
