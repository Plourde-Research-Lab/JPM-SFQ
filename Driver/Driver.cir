* Generated by Xic from cell Driver
.tran .1p 450p
.plot tran v(8) v(15)
.include Driver_models.inc
.tran 0.1e-12 450e-12
.plot v(13) v(1)
.options temp=-272
.model jjm jj(rtype=1,cct=1,icon=10m,vg=2.8m,delv=0.08m,
+ icrit=1.00E-5,r0=30,rn=30,cap=50f)
b1 1 2 14 jj1 area=3.00E+0
b2 7 12 11 jj1 area=4.00E+0
b3 9 10 17 jj1 area=4.00E+0
b4 5 6 16 jj1 area=5.50E+0
ibias 0 13 8.25E-5
itrig 8 0 sin(0 4.47E-5 5e9 50e-12 0)
l2 8 3 1.39E-11
l4 3 1 5.38E-12
l5 3 9 5.27E-12
l6 2 4 4.72E-12
l8 9 0 31.0E-12
l10 2 7 8.78E-13
l13 4 5 7.24E-12
lpi1 13 4 3.29E-13
lpj2 12 0 7.68E-13
lpj3 10 11 2.85E-12
lpj4 6 0 5.49E-13
r1 1 2 5.50E+0
r2 11 12 3.68E+0
r3 9 10 2.97E+0
r4 5 6 2.97E+0
rload 8 0 50
.model jj1 jj(rtype=1, cct=1, icon=10m, vg=2.8m, delv=0.08m,
+ icrit=1m, r0=30, rn=1.7, cap=123.3p)
