* Generated by Xic from cell Driver
.tran .1p 450p
.plot tran v(5) v(15)
.include Driver_models.inc
.options temp=-272
.model jjm jj(rtype=1,cct=1,icon=10m,vg=2.8m,delv=0.08m,
+ icrit=1.00E-5,r0=30,rn=30,cap=50f)
b1 10 2 14 jjm area=3.00E+0
b2 4 13 8 jjm area=4.00E+0
b3 6 7 17 jjm area=4.00E+0
b4 11 12 16 jjm area=5.50E+0
ibias 0 9 82.5u
itrig 5 0 sin(0 4.47E-5 5e9 50e-12 0)
l2 5 1 1.39E-11
l4 1 10 5.38E-12
l5 1 6 5.27E-12
l6 2 3 4.72E-12
l8 6 0 31.0E-12
l10 2 4 8.78E-13
l13 3 11 7.24E-12
lpi1 9 3 3.29E-13
lpj2 13 0 7.68E-13
lpj3 7 8 2.85E-12
lpj4 12 0 5.49E-13
rload 5 0 50
